# Keil uVision project FFSample.uvproj, settings and files
target Simulator (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=1
  c define: STM32F10X_HD __USE_LCD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group StartUp
    ./: startup_stm32f10x_hd.s system_stm32f10x.c
  group Source Files
    ./: GLCD_16bitIF_STM32.c IRQ.c LED_Functions.c LCD_Functions.c ff.c mmc_32f1.c Retarget.c rtc_32f1.c Serial.c system_stm32f10x.c uart_32f1.c xprintf.c FFSample.c main.c
  group Documentation
    ./: Abstract.txt
target MCBSTM32E Flash (ARM-ADS)
  device: STM32F103ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=1
  c define: STM32F10X_HD __USE_LCD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
target MCBSTM32E RAM (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: STM32F10X_HD __USE_LCD
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x8000
  memory RVCT9: RAM 0x20008000 size 0x8000
target MCBSTM32E Trace (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: STM32F10X_HD __USE_LCD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
